PACKAGECONFIG ?= "pcap pcre"
PACKAGECONFIG[nmapfe] = ",--without-nmapfe,"

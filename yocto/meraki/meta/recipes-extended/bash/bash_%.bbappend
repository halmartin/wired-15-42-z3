# disable bash as /bin/sh
ALTERNATIVE_PRIORITY[sh] = "1"
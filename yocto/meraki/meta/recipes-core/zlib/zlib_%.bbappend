FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"
SRC_URI += "file://200-fix_shared_build.patch"

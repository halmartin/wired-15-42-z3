require strongswan.inc

SRC_URI[md5sum] = "befb5e827d02433fea6669c20e11530a"
SRC_URI[sha256sum] = "a14dc0d92634ed52730bfc76a76db30943a28ed3c65a560066e1e9f785827b13"

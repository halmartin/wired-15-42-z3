SRC_URI = " \
    https://dl.meraki.net/${BPN}-${PV}.tar.gz \
    file://not-win32.patch \
    file://0001-mips-Use-compiler-internal-define-for-linux.patch \
    file://0001-mips-fix-MIPS-softfloat-build-issue.patch \
"


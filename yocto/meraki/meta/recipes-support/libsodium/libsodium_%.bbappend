EXTRA_OECONF += "--disable-ssp --enable-minimal"
